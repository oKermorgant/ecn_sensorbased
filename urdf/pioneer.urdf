Commit message: cam jac ok, US jac needs to be improved

File: urdf/pioneer.urdf (robot description, URDF)
Before this commit: robot scara, 5 links, 4 joints
Links:
- added link wheels
Joints:
- added joint wheels: type fixed, parent wheels, child base_link, origin xyz=-0.044515 0 0.0 rpy=0 0 0
